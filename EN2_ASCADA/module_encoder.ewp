# IAR project module_encoder.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x40
  General.SCCStackSize: 0xD0
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m88 ATmega88
  ICCAVR.CCDefines: IAR_COMP
  ICCAVR.newCCIncludePaths: f:\PROJECTs\AVR\kvantModules\Kvant\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 2
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm48.xcl
  XLINK.XExtraOptions: -Ointel-standard,(CODE)=.hex; -Ointel-standard,(XDATA)=.eep
configuration Release (AVR, debug)
  as the first configuration, except:
  General.SCCStackSize: 0x180
  General.SCRStackSize: 64
  General.LCNearHeapSize: 0x30
  group (top)
    ../LIB_SH/LIB_BLINK/: blink.c
    ./: main.c
  group ModBUS_Lib
    ../LIB_SH/LIBS_MODBUS/: modbus.c modbus_crc.c
