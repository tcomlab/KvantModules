# IAR project Backup (2) of module_termopare.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0xFF
  General.SCRStackSize: 32
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m88 ATmega88
  ICCAVR.CCDefines: IAR_COMP
  ICCAVR.newCCIncludePaths: e:\PROJECTs\AVR\kvantModules\Kvant\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm88.xcl
  XLINK.XExtraOptions: -Ointel-standard,(CODE)=.hex; -Ointel-standard,(XDATA)=.eep
  group (top)
    ../LIB_SH/LIB_BLINK/: blink.c
    ./: main.c
  group ModBUS_Lib
    ../LIB_SH/LIBS_MODBUS/: modbus.c modbus_crc.c
